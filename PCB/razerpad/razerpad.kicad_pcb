# Repository shubhisroking/razerpad

File README.md:

# razerpad
Macropad with razer branding

Inspiration:
I use XMONAD so mostly for that

Challenges
Very first time using kicad and fusion. I ran into some issues tho but tutorial was quite helpful also hackpad already had most of my questions answered

Schematics

PCB

Top case

Bottom Case

Final assembly

BOM:

6x Cherry MX Switches
2x SK6812 LED
1x XIAO RP2040 DIP
4x Keycaps
4x M3x16 Bolt
4x M3 Heatset

## KiCad design PCB/razerpad/razerpad.kicad_pcb

Parts:
D1, D2: SK6812MINI; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm
SW1, SW2, SW3, SW4, SW5, SW6: SW_Push; SW_Cherry_MX_1.00u_PCB
U1: XIAO-RP2040-DIP

Connections:
+5V: D1.4 (VDD), D2.4 (VDD), U1.14 (VBUS)
GND: D1.2 (VSS), D2.2 (VSS), SW1.1, SW2.1, SW3.1, SW4.1, SW5.1, SW6.1, U1.13 (GND)
unnamed: D1.3 (DIN), U1.5 (GPIO6/SDA)
unnamed: D1.1 (DOUT), D2.3 (DIN)
unnamed: SW5.2, U1.7 (GPIO0/TX)
unnamed: SW1.2, U1.8 (GPIO1/RX)
unnamed: SW2.2, U1.9 (GPIO2/SCK)
unnamed: SW4.2, U1.11 (GPIO3/MOSI)
unnamed: SW3.2, U1.10 (GPIO4/MISO)
unnamed: SW6.2, U1.6 (GPIO7/SCL)

Board: 2 copper layers, 60.0 x 70.0 mm, 9 parts (0 on the bottom side), 10 nets.

File PCB/razerpad/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"D1, D2",LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm,2,SK6812MINI,
"SW1, SW2, SW3, SW4, SW5, SW6",SW_Cherry_MX_1.00u_PCB,6,SW_Push,
U1,XIAO-RP2040-DIP,1,XIAO-RP2040-DIP,

## Commit log

2025-06-14 initial PCB
2025-06-14 some seed related stuff
2025-06-14 move XIAO library to our PCB folder
2025-06-17 add PCB
2025-07-03 alright
2025-07-03 move gerber to prod folder
2025-07-03 move stl files to cad
2025-07-03 alright I am done
2025-07-03 add some ss
2025-07-03 lttle update
2025-07-04 add final assembly
